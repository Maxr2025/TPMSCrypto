options:
  parameters:
    generate_options: qt_gui
    id: RX_GFSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rx_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '100'
    value: '1'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: 1.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 386e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: recieved_data.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_gain
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '0010110111010100'
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: firdes.low_pass(gain=1,sampling_freq=rx_samp_rate,cutoff_freq=100e3,transition_width=20e3,window=window.WIN_HAMMING)
    decim: int(rx_samp_rate)
    interp: int(samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_1
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: rx_freq
    samp_rate: rx_samp_rate
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_gfsk_demod_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_const_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [soapy_rtlsdr_source_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
