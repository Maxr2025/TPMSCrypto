options:
  parameters:
    generate_options: qt_gui
    id: RX_GFSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: rx_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: 1.8e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 386e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.pkt
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rx_freq
    samp_rate: rx_samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_char_to_float_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
