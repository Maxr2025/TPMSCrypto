options:
  parameters:
    generate_options: qt_gui
    id: TX_GFSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filt_cutoff
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: samp_rate/2
    value: 20e3
  states: {}
- name: filt_gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '10'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 386e3
  states: {}
- name: samp_rate_rtl
  id: variable
  parameters:
    value: 1.8e6
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: squel
  id: variable_qtgui_range
  parameters:
    start: '-50'
    step: '1'
    stop: '50'
    value: '-10'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: tx_mult
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squel
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.pkt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test_packet.pkt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mult
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filt_cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 8e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: filt_cutoff
    decim: '1'
    gain: filt_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 8e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    label1: Signal 1 Pre Filt
    label2: Signal 2 Pre Filt
    label3: Signal 1 Post Filt
    label4: Signal 2 Post Filt
    nconnections: '2'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_rtl
    fc: tx_freq
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Pre Filt
    label2: Post Filt
    name: TX FFT
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Post Filt Scope
    size: sps*10
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Pre Filt Scope
    size: sps*10
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_rtl
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate_rtl
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(samp_rate_tx)
    type: ccf
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: tx_freq
    samp_rate: samp_rate_tx
    type: fc32
    vga: '0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: tx_freq
    dev_args: rtl=0
    samp_rate: samp_rate_rtl
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_mod_0, '0', low_pass_filter_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1, '1']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_eye_sink_x_0, '1']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_2, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
