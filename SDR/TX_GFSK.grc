options:
  parameters:
    generate_options: qt_gui
    id: TX_GFSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 386e3
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: tx_mult
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test_packet.pkt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_mult
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Pre Filt
    label2: Post Filt
    name: TX FFT
    nconnections: '2'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(samp_rate_tx)
    type: ccf
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: tx_freq
    samp_rate: samp_rate_tx
    type: fc32
    vga: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_1, '1']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
